x1 net1 net2 rcnet r=1 c={cpar}
x2 net1 net2 rcnet
x3 a b c d e f g h subname k=1 n=2 i=8 o={oval}
