d1 netp netm diomod area=1e-3 lm=1e-6 temp=25
d2 netp netm diomod area=1e-3 lm=1e-6 temp=25 off
d3 netp netm diomod area={area} lm=1e-6 temp=25 off
