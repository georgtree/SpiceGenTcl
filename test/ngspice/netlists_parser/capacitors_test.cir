c2 netp netm 1e-6
c3 netp netm c={V(a)+V(b)+pow(V(c), 2)} tc1=1
c4 netp netm q={V(a)+V(b) + pow(V(c),2)} tc1=1
c5 netp netm capmod l=1e-6 w=10e-6 temp=25
c1 netp netm 1e-6 tc1=1 temp=25
c6 netp netm q='V(a)+V(b) + pow(V(c),2)' tc1=1 tc2=3
c7 netp netm c=V(a)+V(b) + pow(V(c),2) tc1=1 tc2=3
