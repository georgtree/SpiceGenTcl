m1 netd netg nets mosfetmod l=1e-6 w=10e-3
m2 netd netg nets netsub mosfetmod l=1e-6 w=10e-3
m3 netd netg nets netsub net5 mosfetmod l=1e-6 w=10e-3
m4 netd netg nets netsub net5 net6 mosfetmod l=1e-6 w=10e-3
m5 netd netg nets netsub net5 net6 net7 mosfetmod l=1e-6 w=10e-3
m6 netd netg nets netsub net5 net6 net7 mosfetmod ic=1,2,3 l=1e-6 w=10e-3
m7 netd netg nets netsub net5 net6 net7 mosfetmod ic=1,{a},3 l=1e-6 w=10e-3
m8 netd netg nets netsub net5 net6 net7 mosfetmod ic=1,2, {b} l=1e-6 w=10e-3
m9 netd netg nets mosfetmod off l=1e-6 w=10e-3
m10 netd netg nets mosfetmod
