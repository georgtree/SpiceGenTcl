l1 netp netm 1e-6 tc1=1 temp=25
l2 netp netm 1e-6
l3 netp netm 1e-6 indm
l4 netp netm indm
l5 netp netm l={V(a)+V(b)+pow(V(c),2)} tc1=1
l6 netp netm {l1*l2} tc1=1
