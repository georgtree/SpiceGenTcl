rs1 11 2 { res }
rs2 3 1 r={V(a)+v(b)/I(b) } tc2=1
rc1 4 8 10k tc1= 2 tc2 = {tcrt }
rc2 5 8 10k
rc3 9 2  10k res1
rc4 4 5 res1 l={l1} w=2u
rc5 4 5 {rpar} res1 l= { l1} w=2u
rb1 netp netm resmod l=1e-6 temp=25
