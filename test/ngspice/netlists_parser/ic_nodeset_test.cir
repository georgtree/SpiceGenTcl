.ic v(1)=5 v(a)={b} h=1
.nodeset v(1)=5 v(a)={b} h=1
