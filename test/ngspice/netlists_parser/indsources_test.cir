V1 10 0 DC 6
V2 10 0 6
V3 10 0 6 AC 1
V4 10 0 6 AC 1 45
V5 10 0 DC 6 AC 1
V6 10 0 DC 6 AC 1 -45
