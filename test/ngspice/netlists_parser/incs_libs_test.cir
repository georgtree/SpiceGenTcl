.include ./libs/mosfets/nmos1
.include './libs/mosfets abv/nmos1'
.lib ./libs/mosfets/nmos1 lib1
.lib './libs/mosfets abv/nmos1' lib2
