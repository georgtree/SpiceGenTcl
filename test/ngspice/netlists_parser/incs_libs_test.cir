.include ./libs/mosfets/Nmos1
.include './libs/mosfets abv/nmos1'
.lib ./libs/mosfets/nmos1 lib1
.lib './Libs/mosfets abv/nmos1' lib2
