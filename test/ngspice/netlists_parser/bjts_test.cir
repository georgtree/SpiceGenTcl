q1 netc netb nete bjtmod area=1e-3 temp=25
q2 netc netb nete nets bjtmod area=1e-3 temp=25 off
q3 netc netb nete nets nettj bjtmod area=1e-3 temp=25
q4 netc netb nete bjtmod
q5 netc netb nete nets bjtmod off
q6 netc netb nete nets nettj bjtmod
q7 netc netb nete nets nettj bjtmod ic=1,2 area=1e-3 temp=25
q8 netc netb nete nets nettj bjtmod ic={a},2 area=1e-3 temp=25
q9 netc netb nete nets nettj bjtmod ic={a},{b} area=1e-3 temp=25
